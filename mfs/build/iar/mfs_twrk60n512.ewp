# IAR project mfs_twrk60n512.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCDefines: MQX_DISABLE_CONFIG_CHECK=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550
  ICCARM.PreInclude: ..\..\..\mqx\source\psp\cortex\psp_abi.h
  ICCARM.CCIncludePath2: ..\..\..\lib\twrk60n512.iar\bsp\Generated_code; ..\..\..\lib\twrk60n512.iar\bsp; ..\..\..\lib\twrk60n512.iar\psp; ..\..\..\lib\twrk60n512.iar; ..\..\..\mqx\source\include; ..\..\source\include; ..\..\..\config\twrk60n512
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  postbuild: "..\bat\mfs.bat" "..\..\..\lib\twrk60n512.iar\mfs\mfs_twrk60n512_d.a" IAR
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: MQX_DISABLE_CONFIG_CHECK=1; NDEBUG
  ICCARM.CCOptLevel: 3
  postbuild: "..\bat\mfs.bat" "..\..\..\lib\twrk60n512.iar\mfs\mfs_twrk60n512.a" IAR
  group twrk60n512 Config in lib
    ../../../lib/twrk60n512.iar/: twrk60n512_lib.txt
  group MFS Source
    ../../source/generic/: dir_read.c mfs_attribute.c mfs_cluster.c mfs_create.c mfs_data_sector.c mfs_delete.c mfs_dir_entry.c mfs_directory.c mfs_fat.c mfs_format.c mfs_handle.c mfs_init.c mfs_lfn.c mfs_misc.c mfs_open.c mfs_parse.c mfs_read.c mfs_rename.c mfs_rw.c mfs_search.c mfs_time.c mfs_valdev.c mfs_write.c part_mgr.c
  group MFS Include
    ../../source/include/: mfs.h mfs_cnfg.h mfs_prv.h mfs_rev.h part_mgr.h
