# IAR project mfs_usb_twrk40x256.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: K40Xxxx Freescale K40Xxxx
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pa082,Pe186
  ICCARM.CCIncludePath2: ..\..\..\..\lib\twrk40x256.iar\bsp; ..\..\..\..\lib\twrk40x256.iar\psp; ..\..\..\..\lib\twrk40x256.iar\bsp\Generated_Code; ..\..\..\..\lib\twrk40x256.iar; ..\..\..\..\lib\twrk40x256.iar\mfs; ..\..\..\..\lib\twrk40x256.iar\usb\host; ..\..\..\..\lib\twrk40x256.iar\shell; ..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ..\..\..\..\lib\twrk40x256.iar\bsp\intflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NDEBUG
  ICCARM.CCOptLevel: 3
configuration Int Ram Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\..\..\..\lib\twrk40x256.iar\bsp\ram.icf
configuration Int Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ..\..\..\..\lib\twrk40x256.iar\bsp\ram.icf
  group MQX Libraries
    ../../../../lib/twrk40x256.iar/bsp/: bsp_twrk40x256_d.a bsp_twrk40x256.a
    ../../../../lib/twrk40x256.iar/psp/: psp_twrk40x256_d.a psp_twrk40x256.a
    ../../../../lib/twrk40x256.iar/: twrk40x256_lib.txt
  group MFS Libraries
    ../../../../lib/twrk40x256.iar/mfs/: mfs_twrk40x256_d.a mfs_twrk40x256.a
  group USB Host Libraries
    ../../../../lib/twrk40x256.iar/usb/host/: usb_hdk_twrk40x256_d.a usb_classes.c usb_hdk_twrk40x256.a
  group Shell Libraries
    ../../../../lib/twrk40x256.iar/shell/: shell_twrk40x256_d.a shell_twrk40x256.a
  group Source
    ../: Command_Lists.c MFS_USB.h Shell_Task.c Tasks.c USB_File.c USB_File.h USB_Task.c USB_Task.h usb_classes.h
