# IAR project flexnvm_twrk40x256.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: K40Xxxx Freescale K40Xxxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pa082,Pe186
  ICCARM.CCIncludePath2: ..\..\..\..\lib\twrk40x256.iar\bsp; ..\..\..\..\lib\twrk40x256.iar\psp; ..\..\..\..\lib\twrk40x256.iar\bsp\Generated_Code; ..\..\..\..\lib\twrk40x256.iar
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: flexnvm_twrk40x256.srec
  ILINK.IlinkOutputFile: flexnvm_twrk40x256.out
  ILINK.IlinkIcfFile: ..\..\..\..\lib\twrk40x256.iar\bsp\intflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NDEBUG
  ICCARM.CCOptLevel: 3
configuration Int Ram Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\..\..\..\lib\twrk40x256.iar\bsp\ram.icf
configuration Int Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ..\..\..\..\lib\twrk40x256.iar\bsp\ram.icf
  group MQX Libraries
    ../../../../lib/twrk40x256.iar/bsp/: bsp_twrk40x256.a bsp_twrk40x256_d.a
    ../../../../lib/twrk40x256.iar/psp/: psp_twrk40x256.a psp_twrk40x256_d.a
    ../../../../lib/twrk40x256.iar/: twrk40x256_lib.txt
  group Source
    ../: flexnvm_demo.c
