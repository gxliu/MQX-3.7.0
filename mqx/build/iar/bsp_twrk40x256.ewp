# IAR project bsp_twrk40x256.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCDefines: MQX_DISABLE_CONFIG_CHECK=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550
  ICCARM.PreInclude: ..\..\source\psp\cortex\psp_abi.h
  ICCARM.CCIncludePath2: ..\..\..\config\common; ..\..\..\config\twrk40x256; ..\..\source\include; ..\..\source\psp\cortex; ..\..\source\bsp\twrk40x256; ..\..\source\io\adc; ..\..\source\io\adc\kadc; ..\..\source\io\can\flexcan; ..\..\source\io\esdhc; ..\..\source\io\flashx; ..\..\source\io\flashx\freescale; ..\..\source\io\gpio; ..\..\source\io\gpio\kgpio; ..\..\source\io\i2c; ..\..\source\io\i2c\int; ..\..\source\io\i2c\polled; ..\..\source\io\io_dun; ..\..\source\io\io_mem; ..\..\source\io\io_null; ..\..\source\io\lcd; ..\..\source\io\lwgpio; ..\..\source\io\pcb; ..\..\source\io\pcb\mqxa; ..\..\source\io\pcb\shmem; ..\..\source\io\rtc; ..\..\source\io\sdcard; ..\..\source\io\sdcard\sdcard_esdhc; ..\..\source\io\sdcard\sdcard_spi; ..\..\source\io\serial; ..\..\source\io\spi\int; ..\..\source\io\spi\polled; ..\..\source\io\spi; ..\..\source\io\tchres; ..\..\source\io\tfs; ..\..\source\io\usb; ..\..\..\config\twrk40x256
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  postbuild: "..\bat\bsp_twrk40x256.bat" "..\..\..\lib\twrk40x256.iar\bsp\bsp_twrk40x256_d.a" IAR
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: MQX_DISABLE_CONFIG_CHECK=1; NDEBUG
  ICCARM.CCOptLevel: 3
  postbuild: "..\bat\bsp_twrk40x256.bat" "..\..\..\lib\twrk40x256.iar\bsp\bsp_twrk40x256.a" IAR
  group twrk40x256 User Config
    ../../../config/twrk40x256/: user_config.h
  group twrk40x256 BSP Files
    ../../source/bsp/twrk40x256/: PE_LDD.h bsp.h bsp_prv.h bsp_rev.h get_nsec.c get_usec.c init_adc.c init_bsp.c init_esdhc.c init_gpio.c init_hw.c init_i2c.c init_sci.c init_sdcard.c init_spi.c init_tchres.c mqx_init.c mqx_main.c twrk40x256.h vectors.c
    ../../source/bsp/twrk40x256/iar/: kernel_data.s
  group Peripheral IO Drivers/adc
    ../../source/io/adc/: adc.c adc.h adc_conf.h adc_prv.h
  group Peripheral IO Drivers/adc/kadc
    ../../source/io/adc/kadc/: adc_kadc.c adc_kadc.h adc_kadc_prv.h adt_kpdb.c
  group Peripheral IO Drivers/flexcan
    ../../source/io/can/flexcan/: flexcan_mk40.c kflexcan.c kflexcan.h kflexcan_int.c
  group Peripheral IO Drivers/esdhc
    ../../source/io/esdhc/: esdhc.c esdhc.h esdhc_mk40.c esdhc_prv.h
  group Peripheral IO Drivers/flashx
    ../../source/io/flashx/: flashx.c flashx.h flashxprv.h
  group Peripheral IO Drivers/flashx/freescale
    ../../source/io/flashx/freescale/: flash_kinetis.c flash_kinetis.h flash_mk40.c flash_mk40.h
  group Peripheral IO Drivers/gpio
    ../../source/io/gpio/: io_gpio.c io_gpio.h io_gpio_prv.h
  group Peripheral IO Drivers/gpio/knxx
    ../../source/io/gpio/kgpio/: io_gpio_kgpio.c io_gpio_kgpio.h io_gpio_kgpio_prv.h
  group Peripheral IO Drivers/i2c
    ../../source/io/i2c/: i2c.h i2c_ki2c.h i2c_ki2c_prv.h i2c_mk40.c
  group Peripheral IO Drivers/i2c/int
    ../../source/io/i2c/int/: i2c_int.c i2c_int_ki2c.c i2c_int_prv.h
  group Peripheral IO Drivers/i2c/polled
    ../../source/io/i2c/polled/: i2c_pol.c i2c_pol_ki2c.c i2c_pol_prv.h
  group Peripheral IO Drivers/lcd
    ../../source/io/lcd/: lcd_twrk40x256.c lcd_twrk40x256.h lcd_twrk40x256_prv.h
  group Peripheral IO Drivers/lwgpio
    ../../source/io/lwgpio/: lwgpio.h
  group Peripheral IO Drivers/lwgpio/kgpio
    ../../source/io/lwgpio/: lwgpio_kgpio.c lwgpio_kgpio.h
  group Peripheral IO Drivers/rtc
    ../../source/io/rtc/: krtc.c krtc.h rtc.h
  group Peripheral IO Drivers/sdcard
    ../../source/io/sdcard/: sdcard.c sdcard.h sdcard_prv.h
  group Peripheral IO Drivers/sdcard/sdcard_esdhc
    ../../source/io/sdcard/sdcard_esdhc/: sdcard_esdhc.c sdcard_esdhc.h
  group Peripheral IO Drivers/sdcard/sdcard_spi
    ../../source/io/sdcard/sdcard_spi/: sdcard_spi.c sdcard_spi.h
  group Peripheral IO Drivers/serial
    ../../source/io/serial/: io_sinit.c serial.h serl_kuart.h serl_mk40.c
  group Peripheral IO Drivers/serial/int
    ../../source/io/serial/int/: serl_int.c serl_int_kuart.c
    ../../source/io/serial/: serinprv.h
  group Peripheral IO Drivers/serial/polled
    ../../source/io/serial/polled/: serl_pol.c serl_pol_kuart.c
    ../../source/io/serial/: serplprv.h
  group Peripheral IO Drivers/spi
    ../../source/io/spi/: spi.h spi_dspi.h spi_dspi_prv.h spi_mk40_dspi.c
  group Peripheral IO Drivers/spi/int
    ../../source/io/spi/int/: spi_int.c spi_int_dspi.c spi_int_prv.h
  group Peripheral IO Drivers/spi/polled
    ../../source/io/spi/polled/: spi_pol.c spi_pol_dspi.c spi_pol_prv.h
  group Peripheral IO Drivers/tchres
    ../../source/io/tchres/: tchres.c tchres.h tchres_prv.h
  group Peripheral IO Drivers/usb
    ../../source/io/usb/: usb_bsp.h usb_mk40.c
  group Generic IO Drivers/io_dun
    ../../source/io/io_dun/: io_dun.c io_dun.h
  group Generic IO Drivers/io_mem
    ../../source/io/io_mem/: io_mem.c io_mem.h iomemprv.h
  group Generic IO Drivers/io_null
    ../../source/io/io_null/: io_null.c io_null.h ionulprv.h
  group Generic IO Drivers/pcb
    ../../source/io/pcb/: io_pcb.c io_pcb.h io_pcb2.c iop_inst.c iopcbprv.h
    ../../source/io/pcb/mqxa/: pcb_mqxa.c pcb_mqxa.h pcbmqxav.h
    ../../source/io/pcb/shmem/: pcb_shm.c pcb_shm.h pcbshmv.h
  group Generic IO Drivers/tfs
    ../../source/io/tfs/: tfs.c tfs.h tfs_prv.h
