# IAR project bsp_twrk60n512.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCDefines: MQX_DISABLE_CONFIG_CHECK=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550
  ICCARM.PreInclude: ..\..\source\psp\cortex\psp_abi.h
  ICCARM.CCIncludePath2: ..\..\..\config\common; ..\..\..\config\twrk60n512; ..\..\source\include; ..\..\source\psp\cortex; ..\..\source\bsp\twrk60n512; ..\..\source\io\adc; ..\..\source\io\adc\kadc; ..\..\source\io\can\flexcan; ..\..\source\io\enet\Phy; ..\..\source\io\enet; ..\..\source\io\enet\macnet; ..\..\source\io\esdhc; ..\..\source\io\flashx; ..\..\source\io\flashx\freescale; ..\..\source\io\gpio; ..\..\source\io\gpio\kgpio; ..\..\source\io\i2c; ..\..\source\io\i2c\int; ..\..\source\io\i2c\polled; ..\..\source\io\io_dun; ..\..\source\io\io_mem; ..\..\source\io\io_null; ..\..\source\io\lwgpio; ..\..\source\io\pcb; ..\..\source\io\pcb\mqxa; ..\..\source\io\pcb\shmem; ..\..\source\io\rtc; ..\..\source\io\sdcard; ..\..\source\io\sdcard\sdcard_esdhc; ..\..\source\io\sdcard\sdcard_spi; ..\..\source\io\serial; ..\..\source\io\spi\int; ..\..\source\io\spi\polled; ..\..\source\io\spi; ..\..\source\io\tchres; ..\..\source\io\tfs; ..\..\source\io\usb; ..\..\..\config\twrk60n512
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  postbuild: "..\bat\bsp_twrk60n512.bat" "..\..\..\lib\twrk60n512.iar\bsp\bsp_twrk60n512_d.a" IAR
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: MQX_DISABLE_CONFIG_CHECK=1; NDEBUG
  ICCARM.CCOptLevel: 3
  postbuild: "..\bat\bsp_twrk60n512.bat" "..\..\..\lib\twrk60n512.iar\bsp\bsp_twrk60n512.a" IAR
  group twrk60n512 User Config
    ../../../config/twrk60n512/: user_config.h
  group twrk60n512 BSP Files
    ../../source/bsp/twrk60n512/: PE_LDD.h bsp.h bsp_prv.h bsp_rev.h get_nsec.c get_usec.c init_adc.c init_bsp.c init_enet.c init_esdhc.c init_gpio.c init_hw.c init_i2c.c init_sci.c init_sdcard.c init_spi.c init_tchres.c mqx_init.c mqx_main.c twrk60n512.h vectors.c
    ../../source/bsp/twrk60n512/iar/: kernel_data.s
  group Peripheral IO Drivers/adc
    ../../source/io/adc/: adc.c adc.h adc_conf.h adc_prv.h
  group Peripheral IO Drivers/adc/kadc
    ../../source/io/adc/kadc/: adc_kadc.c adc_kadc.h adc_kadc_prv.h adt_kpdb.c
  group Peripheral IO Drivers/flexcan
    ../../source/io/can/flexcan/: flexcan_mk60.c kflexcan.c kflexcan.h kflexcan_int.c
  group Peripheral IO Drivers/enet
    ../../source/io/enet/: enaddr.c enclose.c enerr.c enet.h enet_rev.h enetprv.h eninit.c enjoin.c enleave.c enmediactl.c enopen.c enrecv.c ensend.c enstat.c enstop.c enutil.c ethernet.h
  group Peripheral IO Drivers/enet/phy
    ../../source/io/enet/Phy/: phy_ksz8041.c phy_ksz8041.h
  group Peripheral IO Drivers/enet/macnet
    ../../source/io/enet/macnet/: macnet_1588.c macnet_1588.h macnet_init.c macnet_join.c macnet_mii.c macnet_prv.h macnet_receive.c macnet_rejoin.c macnet_rev.h macnet_send.c macnet_stop.c macnet_util.c
  group Peripheral IO Drivers/enet/macnet_kinetis
    ../../source/io/enet/macnet/: macnet_mk60.c macnet_mk60.h
  group Peripheral IO Drivers/esdhc
    ../../source/io/esdhc/: esdhc.c esdhc.h esdhc_mk60.c esdhc_prv.h
  group Peripheral IO Drivers/flashx
    ../../source/io/flashx/: flashx.c flashx.h flashxprv.h
  group Peripheral IO Drivers/flashx/freescale
    ../../source/io/flashx/freescale/: flash_kinetis.c flash_kinetis.h flash_mk60.c flash_mk60.h
  group Peripheral IO Drivers/gpio
    ../../source/io/gpio/: io_gpio.c io_gpio.h io_gpio_prv.h
  group Peripheral IO Drivers/gpio/knxx
    ../../source/io/gpio/kgpio/: io_gpio_kgpio.c io_gpio_kgpio.h io_gpio_kgpio_prv.h
  group Peripheral IO Drivers/i2c
    ../../source/io/i2c/: i2c.h i2c_ki2c.h i2c_ki2c_prv.h i2c_mk60.c
  group Peripheral IO Drivers/i2c/int
    ../../source/io/i2c/int/: i2c_int.c i2c_int_ki2c.c i2c_int_prv.h
  group Peripheral IO Drivers/i2c/polled
    ../../source/io/i2c/polled/: i2c_pol.c i2c_pol_ki2c.c i2c_pol_prv.h
  group Peripheral IO Drivers/lwgpio
    ../../source/io/lwgpio/: lwgpio.h
  group Peripheral IO Drivers/lwgpio/kgpio
    ../../source/io/lwgpio/: lwgpio_kgpio.c lwgpio_kgpio.h
  group Peripheral IO Drivers/rtc
    ../../source/io/rtc/: krtc.c krtc.h rtc.h
  group Peripheral IO Drivers/sdcard
    ../../source/io/sdcard/: sdcard.c sdcard.h sdcard_prv.h
  group Peripheral IO Drivers/sdcard/sdcard_esdhc
    ../../source/io/sdcard/sdcard_esdhc/: sdcard_esdhc.c sdcard_esdhc.h
  group Peripheral IO Drivers/sdcard/sdcard_spi
    ../../source/io/sdcard/sdcard_spi/: sdcard_spi.c sdcard_spi.h
  group Peripheral IO Drivers/serial
    ../../source/io/serial/: io_sinit.c serial.h serl_kuart.h serl_mk60.c
  group Peripheral IO Drivers/serial/int
    ../../source/io/serial/int/: serl_int.c serl_int_kuart.c
    ../../source/io/serial/: serinprv.h
  group Peripheral IO Drivers/serial/polled
    ../../source/io/serial/polled/: serl_pol.c serl_pol_kuart.c
    ../../source/io/serial/: serplprv.h
  group Peripheral IO Drivers/spi
    ../../source/io/spi/: spi.h spi_dspi.h spi_dspi_prv.h spi_mk60_dspi.c
  group Peripheral IO Drivers/spi/int
    ../../source/io/spi/int/: spi_int.c spi_int_dspi.c spi_int_prv.h
  group Peripheral IO Drivers/spi/polled
    ../../source/io/spi/polled/: spi_pol.c spi_pol_dspi.c spi_pol_prv.h
  group Peripheral IO Drivers/tchres
    ../../source/io/tchres/: tchres.c tchres.h tchres_prv.h
  group Peripheral IO Drivers/usb
    ../../source/io/usb/: usb_bsp.h usb_mk60.c
  group Generic IO Drivers/io_dun
    ../../source/io/io_dun/: io_dun.c io_dun.h
  group Generic IO Drivers/io_mem
    ../../source/io/io_mem/: io_mem.c io_mem.h iomemprv.h
  group Generic IO Drivers/io_null
    ../../source/io/io_null/: io_null.c io_null.h ionulprv.h
  group Generic IO Drivers/pcb
    ../../source/io/pcb/: io_pcb.c io_pcb.h io_pcb2.c iop_inst.c iopcbprv.h
    ../../source/io/pcb/mqxa/: pcb_mqxa.c pcb_mqxa.h pcbmqxav.h
    ../../source/io/pcb/shmem/: pcb_shm.c pcb_shm.h pcbshmv.h
  group Generic IO Drivers/tfs
    ../../source/io/tfs/: tfs.c tfs.h tfs_prv.h
