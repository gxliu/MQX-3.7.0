# IAR project audio_stream_twrk40x256.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: K40Xxxx Freescale K40Xxxx
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pa082,Pe186
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\lib\twrk40x256.iar\bsp; ..\..\..\..\..\..\lib\twrk40x256.iar\psp; ..\..\..\..\..\..\lib\twrk40x256.iar\bsp\Generated_Code; ..\..\..\..\..\..\lib\twrk40x256.iar; ..\..\..\..\..\..\lib\twrk40x256.iar\usb\host; ..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\lib\twrk40x256.iar\bsp\intflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NDEBUG
  ICCARM.CCOptLevel: 3
configuration Int Ram Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\lib\twrk40x256.iar\bsp\ram.icf
configuration Int Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\lib\twrk40x256.iar\bsp\ram.icf
  group MQX Libraries
    ../../../../../../lib/twrk40x256.iar/bsp/: bsp_twrk40x256_d.a bsp_twrk40x256.a
    ../../../../../../lib/twrk40x256.iar/psp/: psp_twrk40x256_d.a psp_twrk40x256.a
    ../../../../../../lib/twrk40x256.iar/: twrk40x256_lib.txt
  group USB Host Libraries
    ../../../../../../lib/twrk40x256.iar/usb/host/: usb_hdk_twrk40x256_d.a usb_classes.c usb_hdk_twrk40x256.a
  group Source
    ../: audio.c audio.h audio_data.c audio_pwm.c audio_pwm.h audio_timer.c audio_timer.h kbi.c kbi.h usb_classes.h
