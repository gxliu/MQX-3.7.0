# IAR project phdc_weighscale_twrk40x256.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: K40Xxxx Freescale K40Xxxx
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pa082,Pe186
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\lib\twrk40x256.iar\bsp; ..\..\..\..\..\..\lib\twrk40x256.iar\psp; ..\..\..\..\..\..\lib\twrk40x256.iar\bsp\Generated_Code; ..\..\..\..\..\..\lib\twrk40x256.iar; ..\..\..\..\..\..\lib\twrk40x256.iar\usb\device; ..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\lib\twrk40x256.iar\bsp\intflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NDEBUG
  ICCARM.CCOptLevel: 3
configuration Int Ram Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\lib\twrk40x256.iar\bsp\ram.icf
configuration Int Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\lib\twrk40x256.iar\bsp\ram.icf
  group MQX Libraries
    ../../../../../../lib/twrk40x256.iar/bsp/: bsp_twrk40x256_d.a bsp_twrk40x256.a
    ../../../../../../lib/twrk40x256.iar/psp/: psp_twrk40x256_d.a psp_twrk40x256.a
    ../../../../../../lib/twrk40x256.iar/: twrk40x256_lib.txt
  group USB Device Libraries
    ../../../../../../lib/twrk40x256.iar/usb/device/: usb_ddk_twrk40x256_d.a usb_ddk_twrk40x256.a
  group Source
    ../: ieee11073_nom_codes.h ieee11073_phd_types.h phd_com_model.c phd_com_model.h usb_descriptor.c usb_descriptor.h weighscale.c weighscale.h
