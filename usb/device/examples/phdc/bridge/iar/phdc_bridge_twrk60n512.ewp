# IAR project phdc_bridge_twrk60n512.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: K60Xxxx Freescale K60Xxxx
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pa082,Pe186
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\lib\twrk60n512.iar\bsp; ..\..\..\..\..\..\lib\twrk60n512.iar\psp; ..\..\..\..\..\..\lib\twrk60n512.iar\bsp\Generated_Code; ..\..\..\..\..\..\lib\twrk60n512.iar; ..\..\..\..\..\..\lib\twrk60n512.iar\rtcs; ..\..\..\..\..\..\lib\twrk60n512.iar\usb\device; ..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\lib\twrk60n512.iar\bsp\intflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NDEBUG
  ICCARM.CCOptLevel: 3
configuration Int Ram Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\lib\twrk60n512.iar\bsp\ram.icf
configuration Int Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\lib\twrk60n512.iar\bsp\ram.icf
  group MQX Libraries
    ../../../../../../lib/twrk60n512.iar/bsp/: bsp_twrk60n512_d.a bsp_twrk60n512.a
    ../../../../../../lib/twrk60n512.iar/psp/: psp_twrk60n512_d.a psp_twrk60n512.a
    ../../../../../../lib/twrk60n512.iar/: twrk60n512_lib.txt
  group RTCS Libraries
    ../../../../../../lib/twrk60n512.iar/rtcs/: rtcs_twrk60n512_d.a rtcs_twrk60n512.a
  group USB Device Libraries
    ../../../../../../lib/twrk60n512.iar/usb/device/: usb_ddk_twrk60n512_d.a usb_ddk_twrk60n512.a
  group Source
    ../: bridge.c bridge.h ieee11073_nom_codes.h ieee11073_phd_types.h phdc_server.c phdc_server.h usb_descriptor.c usb_descriptor.h
